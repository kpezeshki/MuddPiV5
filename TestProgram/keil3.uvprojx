# Keil uVision project keil3.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ATSAM4S4B Microchip
  pack: Keil.SAM4_DFP.1.6.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00400000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: keil3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c easySamIO.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.1.2
