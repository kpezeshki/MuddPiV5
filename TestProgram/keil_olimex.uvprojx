# Keil uVision project keil_olimex.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ATSAM3S4B Microchip
  pack: Atmel.SAM3S_DFP.1.0.70
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x00400000,0x00040000) IROM2(0x00800000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: keil_olimex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT5: ROM 0x800000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
