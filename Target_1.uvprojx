# Keil uVision project Target_1.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAM3S4B Microchip
  pack: Atmel.SAM3S_DFP.1.0.70
  cpu: IRAM(0x20000000,0xc000) IROM(0x400000,0x40000) IROM2(0x800000,0x400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: testSort
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: RAM 0x400000 size 0x40000
  memory RVCT5: RAM 0x800000 size 0x400000
  memory RVCT9: ROM 0x20000000 size 0xc000
  group Source Group 1
    ./: sort2.s
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
